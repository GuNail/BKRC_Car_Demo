# Keil uVision project CarV1.uvprojx, settings and files
target CarV1.2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CarV1.3 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\HARDWARE\Task_Board;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\Core_Board;..\HARDWARE\CAN;..\my_lib;..\SYSTEM\timer;..\HARDWARE\Full;..\USER;..\USER\function;..\USER\function\Dao_Zha;..\USER\function\LED_DIS;..\USER\function\3D_DIS;..\USER\function\Wu_Xian;..\USER\function\TFT;..\USER\function\ETC;..\USER\function\Che_Ku;..\USER\function\Jiao_Tong;..\USER\function\Feng_huo;..\USER\function\Lu_Deng;..\USER\function\SYN;..\USER\function\DEBUG;..\USER\function\Data_proce;..\USER\function\Fun_motor;..\USER\function\A72;..\USER\data_base;..\USER\function\SYN;..\USER\function\AGV_Car;..\DSP_LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c plan.c readme.txt
  group Fun
    ../USER/function/Fun_motor/: Fun_motor.c
    ../USER/function/A72/: A72.c
    ../USER/function/AGV_Car/: AGV_Car.c
    ../USER/function/Dao_Zha/: Dao_Zha.c
    ../USER/function/LED_DIS/: LED_DIS.c
    ../USER/function/3D_DIS/: 3D_DIS.c
    ../USER/function/Wu_Xian/: WU_Xian.c
    ../USER/function/TFT/: TFT.c
    ../USER/function/ETC/: ETC.c
    ../USER/function/Che_Ku/: Che_Ku.c
    ../USER/function/Jiao_Tong/: Jiao_Tong.c
    ../USER/function/Feng_huo/: Feng_huo.c
    ../USER/function/Lu_Deng/: Lu_Deng.c
    ../USER/function/DEBUG/: DEBUG.c
    ../USER/function/Data_proce/: Data_proce.c
    ../USER/function/SYN/: Yu_Ying.c
  group HARDWARE
    ../HARDWARE/Task_Board/: infrared.c syn7318.c tba.c ultrasonic.c bh1750.c
    ../HARDWARE/Core_Board/: cba.c usart.c power_check.c uart_a72.c uart_drv.c RC522.C
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: Timer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group my_lib
    ../my_lib/: my_lib.c data_base.c roadway_check.c data_filtering.c
  group CAN
    ../HARDWARE/CAN/: can_drv.c CanP_HostCom.c fifo_drv.c Hard_Can.c can_user.c Can_check.c
  group MATH_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
